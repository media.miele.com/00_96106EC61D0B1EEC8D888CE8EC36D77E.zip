Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-10-21T07:48:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 21 07:48:08 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{9B0DF0C3-A705-4EA5-9928-85CE8141CF18}\ifc * Database version: 5507 * Database creation date: Thu Oct 21 07:48:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 21 07:48:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 21 07:48:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 24724040_USA_11845600_M7240TC_EDST-CLST, 11845600_USA_M7240TC_EDST-CLST:24724040_USA_11845600_M7240TC_EDST-CLST:205444
In: Level 1
Type - Classification: M7000 (Uniformat); Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 24724040_USA_11845600_M7240TC_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
